Commit message: twelve commit

File: assets/kinematics/arm.urdf (robot description, URDF)
Before this commit: robot robot_arm, 14 links, 13 joints
Joints:
- joint tool_center_joint: origin xyz=0.0004 0.007 0.0752 rpy=0 0 0 -> xyz=0.0004 0.007 0.1552 rpy=0 0 0
